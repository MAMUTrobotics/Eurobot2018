<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\STM32F334R8-Nucleo\Project.ewp</path>
  </project>
  <batchBuild/>
</workspace>


